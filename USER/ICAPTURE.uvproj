# Keil uVision project ICAPTURE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ICAPTURE +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE;..\SYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: usart.c Led.c Key.c StepperMotor.c FreePole.c MINI256Z.c PID.c MYDMA.c
  group SYSTEM
    ../SYS/: Delay.c Sys.c TIM4.c TIM2_CH4_PWM.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c
  group Document
    ../Document/: Readme.txt USART_Commod.txt PhysicalConnection.txt
